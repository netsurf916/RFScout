## main/Kconfig.projbuild
```kconfig
menu "RFScout hardware"

comment "Supported board profile is detected automatically at startup"

endmenu
```
